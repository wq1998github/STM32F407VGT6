# Keil uVision project Demo.uvprojx, settings and files
target Demo (5060960::V5.06 update 7 (build 960)::.\ARMCC5)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Demo +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\..\..\STM32F4xx_DSP_StdPeriph_Lib\CMSIS\CoreSupport\Include;..\..\..\STM32F4xx_DSP_StdPeriph_Lib\CMSIS\DeviceSupport\Include;..\..\..\STM32F4xx_DSP_StdPeriph_Lib\STM32F4xx_StdPeriph_Driver\inc;..\..\..\BSP\Include;..\..\..\Middleware;..\Application\AppMain\Inc;..\..\..\Middleware\FreeRTOS\Core\Include;..\..\..\Middleware\FreeRTOS\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../../STM32F4xx_DSP_StdPeriph_Lib/CMSIS/Startup/: startup_stm32f40xx.s
  group CMSIS
    ../../../STM32F4xx_DSP_StdPeriph_Lib/CMSIS/CoreSupport/Include/: core_cm4.h
    ../../../STM32F4xx_DSP_StdPeriph_Lib/CMSIS/DeviceSupport/Include/: stm32f4xx.h system_stm32f4xx.h
    ../../../STM32F4xx_DSP_StdPeriph_Lib/CMSIS/DeviceSupport/Source/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../../STM32F4xx_DSP_StdPeriph_Lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group BSP
    ../../../BSP/Source/: bsp_led.c bsp_system.c bsp_systick.c bsp_uart.c
  group FreeRTOS/Core
    ../../../Middleware/FreeRTOS/Core/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/portable
    ../../../Middleware/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../Middleware/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
  group AppMain
    ../Application/AppMain/Src/: main.c stm32f4xx_it.c
